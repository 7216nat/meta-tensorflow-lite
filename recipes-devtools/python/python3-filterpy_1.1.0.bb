LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=aca3f86f74ee6b7192a6dd568233da12"

PYPI_PACKAGE = "filterpy"

SRC_URI[sha256sum] = "d884b5a305c31a006ef36833f1ed407576160a2b0387f2565a5b934a2063cc1d"

inherit pypi setuptools3