LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=0b7a5474f29bf834c753d80736d3a6b2"

PYPI_PACKAGE = "svgwrite"

PYPI_PACKAGE_EXT = "zip"

SRC_URI[sha256sum] = "a8fbdfd4443302a6619a7f76bc937fc683daf2628d9b737c891ec08b8ce524c3"

inherit pypi setuptools3