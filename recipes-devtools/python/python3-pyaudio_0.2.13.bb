LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=4682050c1a445df1e25ead1604d50cb6"

PYPI_PACKAGE = "PyAudio"

SRC_URI[sha256sum] = "26bccc81e4243d1c0ff5487e6b481de6329fcd65c79365c267cef38f363a2b56"

inherit pypi